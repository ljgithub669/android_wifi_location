# Keil uVision project ATK_ESP8266.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ATK_ESP8266 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\ATK_ESP8266;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\24CXX;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\USART3;..\HARDWARE\W25QXX;..\MALLOC;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TEXT;..\USMART;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\DMA;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\STM32F10x_FWLib\inc;..\USER;..\HARDWARE\mpu6050_1;..\HARDWARE\Led_1;..\HARDWARE\i2c_1;..\HARDWARE\SysTick;..\HARDWARE\usart_1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TOUCH/: ctiic.c ott2001a.c touch.c gt9147.c ft5206.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SysTick/: bsp_SysTick.c
    ../HARDWARE/mpu6050_1/: mpu6050.c
    ../HARDWARE/Led_1/: bsp_led.c
    ../HARDWARE/i2c_1/: bsp_i2c.c
    ../HARDWARE/usart_1/: bsp_usart.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group ATK_ESP866
    ../ATK_ESP8266/: apsta.c common.c wifiap.c wifista.c
  group README
    ../: README.TXT
  group LIB
    ../STM32F10x_FWLib/src/: stm32f10x_rtc.c stm32f10x_gpio.c stm32f10x_i2c.c misc.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_rcc.c
